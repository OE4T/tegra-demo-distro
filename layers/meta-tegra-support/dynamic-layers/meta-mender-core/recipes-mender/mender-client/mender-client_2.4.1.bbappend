# Work around change in PACKAGECONFIG usage
# See https://tracker.mender.io/browse/MEN-4192
PACKAGECONFIG:remove = "inventory-network-scripts"
