PACKAGECONFIG_append = " machine-id"
