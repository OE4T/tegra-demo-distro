FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
RDEPENDS_${PN} += "tegra-redundant-boot-nvbootctrl"
