RDEPENDS_${PN}_remove = "tegra-redundant-boot"
RDEPENDS_${PN}_append = " tegra-boot-tools-updater"
