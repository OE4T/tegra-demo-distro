FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

RDEPENDS:${PN} += "tegra-boot-tools"
