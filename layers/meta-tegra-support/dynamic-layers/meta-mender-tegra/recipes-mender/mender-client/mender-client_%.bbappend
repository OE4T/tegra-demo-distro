EXTRADEPS = ""
EXTRADEPS_tegra = "tegra-boot-tools"
EXTRADEPS_tegra210 = ""
RDEPENDS_${PN} += "${EXTRADEPS}"
