PACKAGECONFIG = "objdetect"
