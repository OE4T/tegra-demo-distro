DEPENDS_append = " python3-pillow-native"
