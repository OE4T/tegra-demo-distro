DEPENDS:append = " python3-pillow-native"
