RRECOMMENDS:${PN}-sshd:remove:tegra = "rng-tools"
RRECOMMENDS:${PN}-sshd:append:tegra = " haveged"
