ROOTFS_POSTPROCESS_COMMAND:remove = "rootfs_version_info;"
