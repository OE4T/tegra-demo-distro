FILESEXTRAPATHS_prepend_tegrademo  := "${THISDIR}/files:"
FILESEXTRAPATHS_prepend_tegrademo-mender  := "${THISDIR}/files:"
SPLASH_IMAGES_tegrademo = "file://psplash-OE4T-img.h;outsuffix=default"
SPLASH_IMAGES_tegrademo-mender = "file://psplash-OE4T-img.h;outsuffix=default"

