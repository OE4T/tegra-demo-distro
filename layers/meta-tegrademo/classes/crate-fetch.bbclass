# XXX
# temporary workaround to disable this bbclass due to issue in OE-Core
# XXX
