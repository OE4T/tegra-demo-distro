IMAGE_FSTYPES:append = " tar.gz"
