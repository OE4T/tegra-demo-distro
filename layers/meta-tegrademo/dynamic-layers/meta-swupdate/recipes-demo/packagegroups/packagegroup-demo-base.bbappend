RDEPENDS:${PN} += "swupdate swupdate-lualoader swupdate-client"
