require demo-image-docker-minimal.inc

# tegra_docker only where docker + the nvidia runtime are installed
TEST_SUITES:append = " tegra_docker"
