# repart is disabled upstream by default; enable it (requires openssl).
PACKAGECONFIG:append = " repart openssl"
