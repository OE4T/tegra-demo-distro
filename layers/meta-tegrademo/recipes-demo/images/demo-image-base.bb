DESCRIPTION = "Tegra demo base image"

require demo-image-common.inc
