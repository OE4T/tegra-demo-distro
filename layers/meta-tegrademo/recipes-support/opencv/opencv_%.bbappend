PSEUDO_IGNORE_PATHS_append = ",${WORKDIR}/contrib"
